# Keil uVision project Blinky.uvproj, settings and files
target SAM9260 Int RAM (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: AT91SAM9260 Atmel
  cpu: IRAM(0x200000-0x200FFF) IRAM2(0x300000-0x300FFF) IROM(0x100000-0x107FFF) CLOCK(18432000) CPUTYPE(ARM926EJ-S)
  output: Blinky
  c flags: Optim=1 v6Lang=1 v6LangP=1
  asm define: SIZE_INT_INFO NO_SDRAM_INIT
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x1000
  memory RVCT9: RAM 0x300000 size 0x1000
  group Startup Code
    ./: SAM9260.s
  group Source Code
    ./: Blinky.c
  group Documentation
    ./: Abstract.txt
target SAM9260 Ext SDRAM (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: AT91SAM9260 Atmel
  cpu: as above
  output: Blinky
  c flags: Optim=1 v6Lang=1 v6LangP=1
  asm define: SIZE_EXT_INFO NO_PMC_INIT NO_EBI_INIT NO_SDRAM_INIT VEC_TO_RAM
  library: MicroLIB
  memory RVCT1: ROM 0x20000000 size 0x83be00
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT6: RAM 0x22000000 size 0x2000000
  memory RVCT9: RAM 0x200000 size 0x1000
  memory RVCT10: RAM 0x300000 size 0x1000
target SAM9260 Ext SDRAM - SAMICE (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: AT91SAM9260 Atmel
  cpu: as above
  output: Blinky
  c flags: Optim=1 v6Lang=1 v6LangP=1
  asm define: as above
  library: MicroLIB
  memory RVCT1: ROM 0x20000000 size 0x83be00
  memory RVCT4: ROM 0x100000 size 0x8000
  memory RVCT6: RAM 0x22000000 size 0x2000000
  memory RVCT9: RAM 0x200000 size 0x1000
  memory RVCT10: RAM 0x300000 size 0x1000
